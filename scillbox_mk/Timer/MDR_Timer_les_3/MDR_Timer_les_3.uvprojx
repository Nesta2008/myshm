# Keil uVision project MDR_Timer_les_3.uvprojx, settings and files
target K1986BE92U (5060960::V5.06 update 7 (build 960)::.\ArmCompiler5Last)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDR_Timer_les_3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: Main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:TIMER 2.2.0i
