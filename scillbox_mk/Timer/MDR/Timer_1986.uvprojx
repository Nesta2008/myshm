# Keil uVision project Timer_1986.uvprojx, settings and files
target K1986BE92U (6190000::V6.19::ARMCLANG)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Timer_1986 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\MDR;.\Init
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main.c
  group Init
    ./Init/: init.c init.h clc.c clc.h tmr.c tmr.h Port.c Port.h SysTick.c SysTick.h PWM.c PWM.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:TIMER 2.2.0i
