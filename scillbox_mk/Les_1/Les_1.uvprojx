# Keil uVision project Les_1.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Les_1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\Les_1;.\Init
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Init
    ./Init/: User_Init.c User_Init.h
  group Main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.2.0i
